# Keil uVision project lab3.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  pack: Keil.Kinetis_SDK_DFP.2.2.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab3
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group Source Group 1
    ./: 3140.s 3140_concur.c 3140_concur.h lab3_t0.c utils.c utils.h process.c
software components: CMSIS:CORE 5.0.0, Device:Startup 2.8
